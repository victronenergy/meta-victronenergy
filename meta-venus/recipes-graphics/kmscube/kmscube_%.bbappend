DEPENDS:remove = "gstreamer1.0 gstreamer1.0-plugins-base"
