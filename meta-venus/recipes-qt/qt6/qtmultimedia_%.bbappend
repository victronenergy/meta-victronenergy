# doesn't build on dunfell with eglfs
PACKAGECONFIG_remove = "gstreamer"
