require qt4_ve_patches.inc
