# no qtxmlpatterns, disables XmlListModel
PACKAGECONFIG = ""
