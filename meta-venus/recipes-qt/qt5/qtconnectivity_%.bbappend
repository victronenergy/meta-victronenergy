FILESEXTRAPATHS_prepend := "${THISDIR}/qtconnectivity:"

SRC_URI += "file://0001-Cache-the-UUID-of-characteristics.patch"
SRC_URI += "file://0002-Wait-for-start-stopDiscovery-call-to-finish.patch"
