FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "\
    file://0001-libblkid-use-ntfs3-as-filesystem-type-for-NTFS.patch \
"
