FILESEXTRAPATHS:prepend := "${THISDIR}/sysvinit:"

SRC_URI += "\
    file://0001-Revert-Allow-multiple-console-output.patch \
"
