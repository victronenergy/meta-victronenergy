FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

# note: there are users which access locale data directly, so it is hard
# to detmine what is used and what not. So just install the default for now.
#PACKAGECONFIG = "make-icudata"
