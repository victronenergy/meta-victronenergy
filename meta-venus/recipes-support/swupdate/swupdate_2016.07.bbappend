SRC_URI += "file://downloader-properly-terminate-after-maximum-retries.patch"
