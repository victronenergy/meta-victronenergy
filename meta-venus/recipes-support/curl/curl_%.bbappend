FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-file-try-reading-from-files-with-no-size.patch"

