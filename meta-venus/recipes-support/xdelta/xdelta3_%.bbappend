PACKAGECONFIG_append = " lzma"
