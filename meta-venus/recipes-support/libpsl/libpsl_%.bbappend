PACKAGECONFIG:remove = "icu"
