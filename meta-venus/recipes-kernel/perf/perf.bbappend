# Scripting won't build since OE hardcodes python3 which isn't available in venus at the moment.
PACKAGECONFIG_remove = "scripting"
