SWUPDATE_INIT = "tiny"

require venus-install-initramfs.inc
