require venus-swu.inc

IMAGE_BASENAME = "venus-swu"
