SUMMARY = "Large Victron image"

require venus-image.inc

IMAGE_OVERHEAD_FACTOR = "1.20"

IMAGE_INSTALL += "\
    packagegroup-venus-large \
"
