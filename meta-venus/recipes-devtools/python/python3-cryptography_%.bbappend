FILESEXTRAPATHS:prepend := "${THISDIR}/python3-cryptography:"

SRC_URI += "file://0001-disable-erroring-on-legacy-ciphers.patch"
