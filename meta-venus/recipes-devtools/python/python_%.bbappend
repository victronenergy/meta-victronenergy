FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://atomically-write-pyc-13146-2.7.patch"
