PACKAGECONFIG:append:class-target = " pgo"

