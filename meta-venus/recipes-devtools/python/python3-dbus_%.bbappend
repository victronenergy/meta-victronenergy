FILESEXTRAPATHS:prepend := "${THISDIR}/python3-dbus:"

SRC_URI += "file://0001-Add-support-for-arg0namespace-in-add_signal_receiver.patch"
