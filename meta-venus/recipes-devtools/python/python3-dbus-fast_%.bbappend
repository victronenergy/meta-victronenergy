DEPENDS += "python3-cython-native"
