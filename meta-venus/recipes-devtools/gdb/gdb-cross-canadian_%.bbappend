gdb_%.bbappend