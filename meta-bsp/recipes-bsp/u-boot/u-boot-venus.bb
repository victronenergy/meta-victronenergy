require u-boot-venus.inc
require ${COREBASE}/meta/recipes-bsp/u-boot/u-boot.inc

DEPENDS += "bc-native dtc-native"

