FIRMWARE_DIR ?= "${nonarch_base_libdir}/firmware"
STAGING_FIRMWARE_DIR = "${STAGING_DIR_HOST}/${FIRMWARE_DIR}"
