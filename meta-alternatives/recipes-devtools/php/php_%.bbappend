FILESEXTRAPATHS_prepend := "${THISDIR}/php:"

PACKAGECONFIG="sqlite3"
