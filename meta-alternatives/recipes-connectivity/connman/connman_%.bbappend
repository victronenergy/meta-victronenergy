INITSCRIPT_PARAMS = "start 70 5 2 3 4 . stop 22 0 1 6 ."
